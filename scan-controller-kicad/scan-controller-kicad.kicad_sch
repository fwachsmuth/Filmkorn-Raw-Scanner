File: scan-controller-kicad/scan-controller-kicad.kicad_sch (KiCad schematic)
At the start: 101 parts, among them CN1 24V in, CN2 Shaft Eye, CN3 Film End Eye, CN4 Lamp, CN5 Fan, CN6 Motor, J1 Shaft Eye, J2 Film End Eye, J3 Raspi GPIO, J4 Raspi UART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

Commit message: Making the Sheet Hierarchical for better overview
Parts:
- removed C1: 100n, LED_SMD:LED_0805_2012Metric, symbol Device:C_Small
- removed C11: 10u, Capacitor_SMD:CP_Elec_5x5.4, symbol Device:C_Polarized_Small
- removed C13, C4, C5, C8: 100n, Capacitor_SMD:C_0805_2012Metric, symbol Device:C_Small
- removed C7: 22u, Capacitor_SMD:CP_Elec_6.3x7.7, symbol Device:C_Polarized_Small
- removed CN2: Shaft Eye, easyeda2kicad:CONN-TH_3P-P2.54_KF141R-2.54-3P, symbol easyeda2kicad:KF141R-2.54-3P
- removed CN3: Film End Eye, easyeda2kicad:CONN-TH_3P-P2.54_KF141R-2.54-3P, symbol easyeda2kicad:KF141R-2.54-3P
- removed CN4: Lamp, easyeda2kicad:CONN-TH_3P-P2.54_KF141R-2.54-3P, symbol easyeda2kicad:KF141R-2.54-3P
- removed CN5: Fan, easyeda2kicad:CONN-TH_3P-P2.54_KF141R-2.54-3P, symbol easyeda2kicad:KF141R-2.54-3P
- removed CN6: Motor, easyeda2kicad:CONN-TH_2P-P5.08_KF142R-5.08-2P, symbol easyeda2kicad:KF142R-5.08-2P
- removed D2, D4: 1N4007, Diode_SMD:D_SOD-123F, symbol Diode:1N4001
- removed D6: Power, LED_SMD:LED_0805_2012Metric, symbol Device:LED_Small
- removed J1: Shaft Eye, Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical, symbol Connector_Generic:Conn_01x03
- removed J2: Film End Eye, Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical, symbol Connector_Generic:Conn_01x03
- removed Q1: IRF7470, Package_SO:SOIC-8_3.9x4.9mm_P1.27mm, symbol Transistor_FET:IRF7403
- removed Q2: BC848, Package_TO_SOT_SMD:SOT-23, symbol Transistor_BJT:BC847
- removed Q5: BC817, Package_TO_SOT_SMD:SOT-23, symbol Transistor_BJT:BC847
- removed R1, R5: 100R, Resistor_SMD:R_0805_2012Metric, symbol Device:R_Small
- removed R10, R23, R29, R3, R4: 47K, Resistor_SMD:R_0805_2012Metric, symbol Device:R_Small
- removed R12, R13: 3K3, Resistor_SMD:R_0805_2012Metric, symbol Device:R_Small
- removed R15: 2K2, Resistor_SMD:R_1210_3225Metric, symbol Device:R_Small
- removed R19: 30K, Resistor_SMD:R_0805_2012Metric, symbol Device:R_Small
- removed R2: 150R, Resistor_SMD:R_0805_2012Metric, symbol Device:R_Small
- removed R21: 220R, Resistor_SMD:R_0805_2012Metric, symbol Device:R_Small
- removed R22, R26, R28, R32: 100K, Resistor_SMD:R_0805_2012Metric, symbol Device:R_Small
- removed R24, R30: 22K, Resistor_SMD:R_0805_2012Metric, symbol Device:R_Small
- removed R25, R31: 10K, Resistor_SMD:R_0805_2012Metric, symbol Device:R_Small
- removed R6, R7: 470K, Resistor_SMD:R_0805_2012Metric, symbol Device:R_Small
- removed R8, R9: 3K, Resistor_SMD:R_0805_2012Metric, symbol Device:R_Small
- removed RV1, RV2, RV3: 10K, easyeda2kicad:RES-ADJ-SMD_RDC506002A, symbol Device:R_Potentiometer_Small
- removed SW1: Power, easyeda2kicad:KEY-TH_4P-L12.0-W12.0-P5.0-LS12.5-EH-small, symbol easyeda2kicad:B3F-5000_sm
- removed SW10: Rec, easyeda2kicad:KEY-TH_4P-L12.0-W12.0-P5.0-LS12.5-EH-small, symbol easyeda2kicad:B3F-5000_sm
- removed SW2: Lamp, easyeda2kicad:KEY-TH_4P-L12.0-W12.0-P5.0-LS12.5-EH-small, symbol easyeda2kicad:B3F-5000_sm
- removed SW3: Zoom, easyeda2kicad:KEY-TH_4P-L12.0-W12.0-P5.0-LS12.5-EH-small, symbol easyeda2kicad:B3F-5000_sm
- removed SW4: <<, easyeda2kicad:KEY-TH_4P-L12.0-W12.0-P5.0-LS12.5-EH-small, symbol easyeda2kicad:B3F-5000_sm
- removed SW5: <, easyeda2kicad:KEY-TH_4P-L12.0-W12.0-P5.0-LS12.5-EH-small, symbol easyeda2kicad:B3F-5000_sm
- removed SW7: Stop, easyeda2kicad:KEY-TH_4P-L12.0-W12.0-P5.0-LS12.5-EH-small, symbol easyeda2kicad:B3F-5000_sm
- removed SW8: >, easyeda2kicad:KEY-TH_4P-L12.0-W12.0-P5.0-LS12.5-EH-small, symbol easyeda2kicad:B3F-5000_sm
- removed SW9: >>, easyeda2kicad:KEY-TH_4P-L12.0-W12.0-P5.0-LS12.5-EH-small, symbol easyeda2kicad:B3F-5000_sm
- removed TP1: KSQ+, TestPoint:TestPoint_THTPad_D3.0mm_Drill1.5mm, symbol Connector:TestPoint
- removed TP2: KSQ-, TestPoint:TestPoint_THTPad_D3.0mm_Drill1.5mm, symbol Connector:TestPoint
- removed TP4: LED+, TestPoint:TestPoint_THTPad_D3.0mm_Drill1.5mm, symbol Connector:TestPoint
- removed TP5: LED-, TestPoint:TestPoint_THTPad_D3.0mm_Drill1.5mm, symbol Connector:TestPoint
- removed TP7: Main Shaft, TestPoint:TestPoint_THTPad_D2.0mm_Drill1.0mm, symbol Connector:TestPoint
- removed TP8: Film End, TestPoint:TestPoint_THTPad_D2.0mm_Drill1.0mm, symbol Connector:TestPoint
- removed U1: 74LVC14, Package_SO:SOIC-14_3.9x8.7mm_P1.27mm, symbol 74xx:74HC14
- removed U2, U3: QRE1113, Peacemans_Footprints:QRE1113GR-slim, symbol Sensor_Proximity:QRE1113
- removed U5: DRV8871DDA, Package_SO:Texas_HTSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.95x4.9mm_Mask2.4x3.1mm_ThermalVias, symbol Driver_Motor:DRV8871DDA
Connections:
- net +24V renamed 24VDC
- net +5V renamed 5V-RPi
- net SDA renamed Power Button
- no-connect marks 16 -> 14
Other:
- added sheet Drivers (drivers.kicad_sch)
- added sheet Sensors (sensors.kicad_sch)
- added sheet User Interface (userinterface.kicad_sch)
- moved on the sheet: Q6, Q7, R16, R17, R18

Commit message: It's getting neat and readable
Parts:
- removed D5: Film End, LED_SMD:LED_0805_2012Metric, symbol Device:LED_Small
- removed R20: 300R, Resistor_SMD:R_0805_2012Metric, symbol Device:R_Small
Connections:
- net Power Button renamed GPIO26
Other:
- removed sheet 5V-3A Regulator
- sheet User Interface ports: added Film End LED; removed none
- moved on the sheet: C10, C12, C14, C15, C16, C17, C9, J3, J4, J5, J6, Q6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

Commit message: Tidiedup schematics!
Other:
- moved on the sheet: C10, C12, C14, C15, C16, C17, C9, J3, J4, J5, J6, Q6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

Commit message: Adding missing components Mfnrs and footprints
Parts:
- C1: renamed from C2; footprint (none) -> easyeda2kicad:CAP-SMD_BD12.5-L13.0-W13.0-RD; LCSC (none) -> C90272
- C2: renamed from C9; LCSC C72515 -> C72515
- CN1: LCSC (none) -> C475144; LCSC Part C475144 -> (none)
- R1: renamed from R16; value 220 -> 220R; LCSC (none) -> C17557
- R2: renamed from R17; LCSC (none) -> C17414
- R3: renamed from R18; LCSC (none) -> C17713
- renumbered C10 to C3, C15 to C4, C16 to C5, C14 to C6, C12 to C7, C17 to C8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
