File: scan-controller-kicad/scan-controller-kicad.kicad_sch (KiCad schematic)
At the start: 32 parts, among them CN1 24V in, J1 Raspi GPIO, J2 Raspi UART, J3 ICSP, J4 FTDI, Q1 IRLML2502, Q2 IRLML6402, SW1 Reset, U1 ATmega328P, Y1 8MHz

Commit message: BOM progress
Parts:
- R1, R2, R3, R4, SW1: Inventory (none) -> B
Other:
- note added: "IRF7389 instead?"
Changed lines of the file:
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@@
     (stroke (width 0) (type default))
+  )
+  (text "IRF7389 instead?" (at 142.24 56.515 0)
+    (effects (font (size 1.27 1.27)) (justify left bottom))
   )
   (label "GNDD" (at 57.15 42.545 0) (fields_autoplaced)
@@
     )
     (property "LCSC" "C14877" (at 188.595 107.95 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Inventory" "" (at 188.595 107.95 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Inventory" "" (at 158.115 92.71 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
     )
     (property "LCSC" "C1804" (at 158.115 97.79 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Inventory" "" (at 158.115 97.79 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Inventory" "" (at 211.455 80.01 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Inventory" "" (at 164.465 95.25 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Inventory" "B" (at 159.385 109.22 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "~" (at 48.26 31.115 0)
+    (property "Datasheet" "https://datasheet.lcsc.com/lcsc/2208091830_ROQANG-RVT1H471M1213_C90272.pdf" (at 48.26 31.115 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Inventory" "" (at 48.26 31.115 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
     )
     (property "LCSC" "" (at 226.06 103.505 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Inventory" "" (at 226.06 103.505 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Inventory" "" (at 217.17 111.125 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
     )
     (property "LCSC" "" (at 48.26 23.495 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Inventory" "" (at 48.26 23.495 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
     (property "LCSC" "" (at 220.98 135.255 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Inventory" "" (at 220.98 135.255 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Inventory" "" (at 182.245 66.04 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Inventory" "" (at 21.59 34.925 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Inventory" "" (at 85.725 132.715 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (instances
@@
     )
     (property "LCSC" "C35165" (at 100.965 117.475 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Inventory" "" (at 100.965 117.475 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Inventory" "B" (at 159.385 115.57 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
     )
     (property "LCSC" "C911077" (at 34.29 31.115 90)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Inventory" "" (at 34.29 31.115 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Inventory" "" (at 85.725 130.175 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (instances
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Inventory" "B" (at 121.285 59.055 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
     )
     (property "LCSC" "" (at 203.835 85.09 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Inventory" "" (at 203.835 85.09 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Inventory" "" (at 86.995 109.855 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (instances
@@
     )
     (property "LCSC" "C17414" (at 125.095 48.26 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Inventory" "B" (at 125.095 48.26 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
     (property "LCSC" "" (at 168.91 138.43 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Inventory" "" (at 168.91 138.43 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Inventory" "" (at 113.665 92.075 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
     )
     (property "LCSC" "C17713" (at 125.095 66.04 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Inventory" "B" (at 125.095 66.04 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Inventory" "" (at 86.995 107.315 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (instances
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Inventory" "" (at 167.005 82.55 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (instances
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Inventory" "" (at 54.61 41.275 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (instances
@@
     )
     (property "LCSC" "C28233" (at 120.015 92.075 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Inventory" "" (at 120.015 92.075 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
     (property "LCSC" "C5364308" (at 130.175 59.055 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Inventory" "" (at 130.175 59.055 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Inventory" "" (at 120.65 102.235 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Inventory" "" (at 132.715 46.355 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: BOM complete!
Parts:
- C1: footprint easyeda2kicad:CAP-SMD_BD12.5-L13.0-W13.0-RD -> easyeda2kicad:IND-SMD_L13.8-W12.6_YSPI13XX; Inventory (none) -> E
- C2: footprint Capacitor_SMD:CP_Elec_5x5.4 -> Capacitor_SMD:C_1206_3216Metric; symbol Device:C_Polarized_Small -> Device:C_Small; Inventory (none) -> B; LCSC C72515 -> C96123
- C3, C4, C5, C6, C7, C8, Y1: Inventory (none) -> B
- D1, J1, Q1, Q2, U1: Inventory (none) -> E
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Inventory" "" (at 188.595 107.95 0)
+    (property "Inventory" "E" (at 188.595 107.95 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Inventory" "" (at 158.115 92.71 0)
+    (property "Inventory" "B" (at 158.115 92.71 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Inventory" "" (at 158.115 97.79 0)
+    (property "Inventory" "B" (at 158.115 97.79 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Inventory" "" (at 211.455 80.01 0)
+    (property "Inventory" "B" (at 211.455 80.01 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Inventory" "" (at 164.465 95.25 0)
+    (property "Inventory" "B" (at 164.465 95.25 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "easyeda2kicad:CAP-SMD_BD12.5-L13.0-W13.0-RD" (at 48.26 31.115 0)
+    (property "Footprint" "easyeda2kicad:IND-SMD_L13.8-W12.6_YSPI13XX" (at 48.26 31.115 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Inventory" "" (at 48.26 31.115 0)
+    (property "Inventory" "E" (at 48.26 31.115 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Inventory" "" (at 217.17 111.125 0)
+    (property "Inventory" "B" (at 217.17 111.125 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Inventory" "" (at 182.245 66.04 0)
+    (property "Inventory" "B" (at 182.245 66.04 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Inventory" "" (at 100.965 117.475 0)
+    (property "Inventory" "E" (at 100.965 117.475 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "~" (at 34.29 31.115 0)
+    (property "Datasheet" "https://datasheet.lcsc.com/lcsc/2308231038_MDD-Microdiode-Electronics--TTR5MF_C911077.pdf" (at 34.29 31.115 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Inventory" "" (at 34.29 31.115 0)
+    (property "Inventory" "E" (at 34.29 31.115 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
   )
-  (symbol (lib_id "Device:C_Polarized_Small") (at 113.665 92.075 0) (unit 1)
+  (symbol (lib_id "Device:C_Small") (at 113.665 92.075 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
     (property "Reference" "C2" (at 111.76 87.63 0)
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "Capacitor_SMD:CP_Elec_5x5.4" (at 113.665 92.075 0)
+    (property "Footprint" "Capacitor_SMD:C_1206_3216Metric" (at 113.665 92.075 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "LCSC" "C72515" (at 113.665 92.075 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Inventory" "" (at 113.665 92.075 0)
+    (property "LCSC" "C96123" (at 113.665 92.075 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Inventory" "B" (at 113.665 92.075 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Inventory" "" (at 120.015 92.075 0)
+    (property "Inventory" "B" (at 120.015 92.075 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Inventory" "" (at 130.175 59.055 0)
+    (property "Inventory" "E" (at 130.175 59.055 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Inventory" "" (at 132.715 46.355 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "Inventory" "E" (at 132.715 46.355 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: Starting PCB Layout
Connections:
- net at CN1.1: now also D1.3; no longer D1.4
- net at CN1.2: now also D1.4; no longer D1.3
Other:
- moved on the sheet: CN1
Changed lines of the file:
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@@
   (junction (at 108.585 86.36) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 48.26 38.735) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 48.26 41.275) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 110.49 117.475) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 93.98 145.415) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 108.585 89.535) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 48.26 38.735) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 48.26 41.275) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 110.49 117.475) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 93.98 145.415) (diameter 0) (color 0 0 0 0)
   )
   (junction (at 164.465 115.57) (diameter 0) (color 0 0 0 0)
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 108.585 102.235) (xy 115.57 102.235))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 86.995 107.315) (xy 95.885 107.315))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 108.585 86.36) (xy 108.585 89.535))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 48.26 41.275) (xy 48.26 42.545))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 108.585 89.535) (xy 108.585 94.615))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 93.98 145.415) (xy 93.98 142.875))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 108.585 86.36) (xy 108.585 89.535))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 173.355 128.27) (xy 169.545 128.27))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 108.585 102.235) (xy 115.57 102.235))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 164.465 115.57) (xy 164.465 109.22))
     (stroke (width 0) (type default))
@@
   )
   (wire (pts (xy 217.17 103.505) (xy 220.98 103.505))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 108.585 94.615) (xy 108.585 89.535))
     (stroke (width 0) (type default))
   )
@@
     )
   )
-  (symbol (lib_id "easyeda2kicad:KF142R-5.08-2P") (at 21.59 34.925 180) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no)
-    (property "Reference" "CN1" (at 21.59 40.64 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Value" "24V in" (at 21.59 29.21 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Footprint" "easyeda2kicad:CONN-TH_2P-P5.08_KF142R-5.08-2P" (at 21.59 26.035 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "https://lcsc.com/product-detail/New-Quadratic-Unclassified-Data_Cixi-Kefa-Elec-KF142R-5-08-2P_C475144.html" (at 21.59 23.495 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "LCSC Part" "" (at 21.59 20.955 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+  (symbol (lib_id "easyeda2kicad:KF142R-5.08-2P") (at 21.59 34.925 0) (mirror y) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no)
+    (property "Reference" "CN1" (at 21.59 29.21 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Value" "24V in" (at 21.59 40.64 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "easyeda2kicad:CONN-TH_2P-P5.08_KF142R-5.08-2P" (at 21.59 43.815 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "https://lcsc.com/product-detail/New-Quadratic-Unclassified-Data_Cixi-Kefa-Elec-KF142R-5-08-2P_C475144.html" (at 21.59 46.355 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LCSC Part" "" (at 21.59 48.895 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
