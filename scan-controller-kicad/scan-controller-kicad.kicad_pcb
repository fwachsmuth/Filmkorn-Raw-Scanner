File: scan-controller-kicad/scan-controller-kicad.kicad_pcb (KiCad board)
At the start: 2 copper layers, 131.3 x 101.6 mm, 136 parts, among them CN1 24V in, CN2 Shaft Eye, CN3 Film End Eye, CN4 Fan, CN5 Motor, CN6 Lamp, J1 Raspi GPIO, J2 Raspi UART, J3 ICSP, J4 FTDI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

Commit message: Controls Art
Parts:
- moved REF** 7.65 mm to (126.4, 144.3)
- moved REFe 7.54 mm to (236.2, 144.3)
- moved REFee 1.27 mm to (236.2, 61.0)
- moved REF** 1.14 mm to (126.5, 61.0)
- renumbered REF** to REFe, REF** to REFee
Other:
- outline, holes or cut-outs redrawn

Commit message: Changes shape to hold the cehapo 5.0" Display as cover
Parts:
- RV1, RV2: footprint easyeda2kicad:RES-ADJ-TH_RK09K1130AJ3 -> easyeda2kicad:RES-TH_RK09K1110A0J
- SW10: footprint easyeda2kicad:KEY-TH_4P-L12.0-W12.0-P5.0-LS12.5-EH-small -> easyeda2kicad:KEY-TH_4P-L7.3-W10.2-P4.50-LS7.0
- moved R20 112.9 mm to (224.1, 48.0), turned to -90 degrees
- moved REF** 112.4 mm to (221.0, 46.5), turned to -90 degrees
- moved R22 108.4 mm to (218.0, 48.0), turned to -90 degrees
- moved U4 107.9 mm to (221.0, 50.2), turned to 180 degrees
- moved J6 105.5 mm to (223.5, 54.0), turned to -90 degrees
- moved REF** 105.0 mm to (209.3, 46.5), turned to -90 degrees
- moved R19 104.8 mm to (212.4, 48.0), turned to -90 degrees
- moved REF** 101.5 mm to (221.0, 55.6), turned to 0 degrees
- moved R21 101.3 mm to (206.3, 48.0), turned to -90 degrees
- moved U3 100.2 mm to (209.3, 50.2), turned to 180 degrees
- moved J5 96.9 mm to (211.9, 54.0), turned to -90 degrees
- moved REF** 93.2 mm to (209.3, 55.6), turned to 0 degrees
- moved REF** 11.9 mm to (124.7, 49.2)
- moved REFee 11.9 mm to (237.8, 49.2)
- moved REF** 8.29 mm to (124.7, 136.2)
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Other:
- board size 131.3 x 101.6 mm -> 122.2 x 113 mm

Commit message: Ripping it ALL apart again
Parts:
- moved TP2 71.5 mm to (261.1, 62.0)
- moved TP1 70.8 mm to (256.0, 62.0)
- moved J4 54.7 mm to (124.9, 57.8), turned to 0 degrees
- moved C10 38.7 mm to (132.7, 102.3), turned to 90 degrees
- moved R4 31.9 mm to (133.5, 97.7), turned to 90 degrees
- moved RV5 31.8 mm to (199.9, 62.7), turned to 0 degrees
- moved RV3 26.4 mm to (179.1, 62.7), turned to 0 degrees
- moved RV4 25.9 mm to (189.5, 62.7), turned to 0 degrees
- moved R32 23.4 mm to (158.9, 87.9), turned to 180 degrees
- moved RV2 23.2 mm to (149.9, 64.6)
- moved SW1 23.0 mm to (135.9, 92.0), turned to 0 degrees
- moved RV1 21.6 mm to (165.6, 64.6)
- moved D2 20.2 mm to (130.1, 58.1), turned to -90 degrees
- moved R17 20.0 mm to (130.1, 63.7), turned to -90 degrees
- moved R31 16.3 mm to (158.9, 84.3), turned to 180 degrees
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Routing:
- net /TX: track 45.3 -> 0.00 mm, vias 3 -> 0
- net /RX: track 47.8 -> 5.67 mm
- net /GPIO26: track 143.3 -> 106.7 mm, vias 8 -> 6
- net /D9: track 49.6 -> 18.5 mm, vias 4 -> 2
- net /~{RST}: track 94.2 -> 63.7 mm, vias 7 -> 6
- net /A6: track 43.6 -> 14.4 mm
- net /A3: track 28.6 -> 5.34 mm
- net Net-(C22-Pad1): track 54.9 -> 35.4 mm
- net /Drivers/Lamp-GND: track 1.83 -> 19.2 mm
- net Net-(J4-Pin_6): track 15.4 -> 0.00 mm
- net Net-(R34-Pad2): track 25.7 -> 12.1 mm, vias 2 -> 0
- net Net-(Q7-G): track 12.5 -> 0.00 mm
- net Net-(U9A--): track 30.2 -> 18.4 mm
- net 3.3V-uC: track 68.0 -> 57.1 mm
- net 24VDC: track 127.6 -> 116.9 mm
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
Commit message: DRC happy again
Parts:
- moved TP2 48.7 mm to (212.4, 61.7)
- moved TP1 48.7 mm to (207.3, 61.7)
- moved C20 13.5 mm to (182.0, 88.0)
- moved TP5 12.7 mm to (203.8, 121.2)
- moved R33 10.6 mm to (181.9, 84.3)
- moved C21 10.4 mm to (182.0, 91.7)
- moved U8 7.50 mm to (174.9, 90.9)
- moved J2 2.53 mm to (196.5, 131.2)
- moved TP6 1.99 mm to (189.5, 130.6)
- moved L1 1.33 mm to (193.9, 91.1)
Routing:
- net /A6: track 14.4 -> 80.3 mm, vias 1 -> 2
- net Net-(D6-K): track 88.7 -> 137.4 mm
- net /TX: track 0.00 -> 40.7 mm, vias 0 -> 1
- net /GPIO26: track 106.7 -> 145.8 mm, vias 6 -> 4
- net /RX: track 5.67 -> 42.1 mm
- net Net-(J4-Pin_6): track 0.00 -> 36.0 mm
- net /A2: track 7.08 -> 40.0 mm, vias 0 -> 1
- net Net-(U9A--): track 18.4 -> 51.1 mm
- net Net-(C22-Pad1): track 35.4 -> 66.3 mm, vias 0 -> 1
- net Net-(R34-Pad2): track 12.1 -> 42.5 mm, vias 0 -> 1
- net /A3: track 5.34 -> 33.0 mm, vias 0 -> 1
- net /~{RST}: track 63.7 -> 91.1 mm, vias 6 -> 7
- net /Drivers/Lamp-GND: track 19.2 -> 40.8 mm, vias 0 -> 1
- net 3.3V-uC: track 57.1 -> 48.6 mm
- net Net-(J1-Pin_11): track 3.49 -> 11.5 mm, vias 0 -> 1
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
Commit message: Labels, Keep-out, L moved away from camera cable
Parts:
- moved D4 13.8 mm to (215.9, 117.6), turned to -90 degrees
- moved Q6 5.77 mm to (212.3, 119.6), turned to 0 degrees
Connections:
- CN2 pad 1: 3.3V-uC -> GND
- CN2 pad 3: GND -> 3.3V-uC
- CN3 pad 1: 3.3V-uC -> GND
- CN3 pad 3: GND -> 3.3V-uC
- CN4 pad 1: 5V-RPi -> Net-(D4-A)
- CN4 pad 3: Net-(D4-A) -> 5V-RPi
Routing:
- net Net-(D4-A): track 32.3 -> 19.2 mm, vias 0 -> 1
- net GND: track 76.7 -> 89.1 mm
- net 3.3V-uC: track 48.6 -> 58.7 mm
- net Net-(CN2-Pad2): track 99.7 -> 95.3 mm
- net 5V-RPi: track 45.1 -> 49.5 mm
- net Net-(Q6-B): track 1.47 -> 3.87 mm
- net Net-(Q5-B): track 86.8 -> 88.8 mm
- net 24VDC: track 124.5 -> 123.3 mm
- net /SCL: track 84.8 -> 84.1 mm
- net Net-(J1-Pin_11): track 11.5 -> 12.1 mm
Other:
- board text added: "- +"
- board text added: "-^+"
- board text added: "24V in"
- board text added: "End"
- board text added: "Fan"
- board text added: "Lamp"
- board text added: "Motor"
- board text added: "Shaft"
- board text added: "~ ~"
