# Repository fwachsmuth/Filmkorn-Raw-Scanner

File README.md:

# Filmkorn Raw-Scanner
## An affordable 12‑Bit 4K Motion Picture Film Scanner

Another DIY film scanner?  
Yes, but this one is different: the Filmkorn Raw Scanner is an open‑source project that enables digitizing small‑gauge films at breathtaking quality for a very low price. The project began in 2020 after a bet on the German [Filmvorführerforum](https://www.filmvorfuehrer.de/topic/31851-challenge-framescanner-f%C3%BCr-350%E2%82%AC-bauen/), when the infamous but similarly priced “Wolverine” film scanner from China (aka Somikon, aka Winait, aka Kodak, aka Hammacher‑Schlemmer) turned out to be an irredeemable film‑scratching disaster: Is it even possible to build a truly high‑quality scanner for under €500?

Yes, it is. Now anyone can build a scanner that digitizes their films gently and in fantastic quality.

## Introduction Video

*(Click to play on Youtube)*

## Links
- You find extensive documentation on the [Project Wiki](https://github.com/fwachsmuth/Filmkorn-Raw-Scanner/wiki) (English and German)
- [Example Demo Video](https://www.youtube.com/watch?v=y674Rku_erA) (compressed, since Youtube)
- [Shop 🛒](https://lectronz.com/products/filmkorn-scanner-controller-board) to get a ready-made and populated Controller PCB and optionally some special accessories
- The latest [Image file](https://github.com/fwachsmuth/Filmkorn-Raw-Scanner/releases) for the Raspberry Pi
- Got your Scanner? [Getting Started](https://github.com/fwachsmuth/Filmkorn-Raw-Scanner/wiki/3.-User-Guide-EN)

**Special offer: Send me detailed photos and a description of converting another projector (Bauer, Eumig, whatever) for publication on this page, and I’ll refund the cost of the Scan‑Controller on request!**

## KiCad design scan-controller/scan-controller-kicad/scan-controller-kicad.kicad_pcb

Parts:
C4: 470u; CAP-SMD_BD12.5-L13.0-W13.0-RD; LCSC C487135
C5, C6, C8, C10, C11, C23: 100n; C_0805_2012Metric; LCSC C28233
C7, C9: 22p; C_0805_2012Metric; LCSC C1804
C24: 47u; C_1206_3216Metric; LCSC C96123
C32: 10u; C_1210_3225Metric; LCSC C5156756
CN1: 24V in; CONN-TH_2P-P5.08_KF142R-5.08-2P; LCSC C475144
D2: TTR5MF; DIO-BG-TH_TTF; LCSC C911077
J1: FTDI; PinHeader_1x06_P2.54mm_Vertical
J5: ICSP; PinHeader_2x03_P2.54mm_Vertical
J6: Raspi UART; PinHeader_1x02_P2.54mm_Vertical
J7: Raspi GPIO; PinSocket_2x20_P2.54mm_Vertical
Q2: IRLML2502; SOT-23; LCSC C347503
Q3: IRLML6402; SOT-23; LCSC C2886430
R12, R15, R50: 10K; R_0805_2012Metric; LCSC C17414
R14: 47K; R_0805_2012Metric; LCSC C17713
R33: 220R; R_0805_2012Metric; LCSC C17557
R41: 10K; R_1206_3216Metric; LCSC C17902
R51: 0R; R_0805_2012Metric; LCSC C17477
SW3: Reset; SW_Push_1P1T_XKB_TS-1187A; LCSC C318884
TP1: 24V; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm_named
TP2, TP11: GND; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm_named
TP4: D7; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm_named
TP5, TP6: TestPoint; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm_named
TP8: D10; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm_named
TP12: GPIO27; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm_named
TP13: GPIO6; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm_named
U5: ATmega328P; TQFP-32_7x7mm_P0.8mm; LCSC C14877
Y1: 8MHz; Crystal_SMD_5032-2Pin_5.0x3.2mm; LCSC C115962

Connections:
3.3V-RPi: J7.1, J7.17; also elsewhere on the board
3.3V-uC: C6.1, C8.1, C10.1, C32.1, J1.3, J5.2 (VCC), Q3.3 (D), R12.1, R51.2, U5.4 (VCC), U5.6 (VCC), U5.18 (AVCC); also elsewhere on the board
5V-RPi: C23.1, C24.1, J7.2, J7.4; also elsewhere on the board
24VDC: C4.1, D2.1 (+), R41.2, TP1.1; also elsewhere on the board
/24VAC-1: CN1.1, D2.3
/24VAC-2: CN1.2, D2.4
/A0: U5.23 (PC0); also elsewhere on the board
/A1: U5.24 (PC1); also elsewhere on the board
/A2: U5.25 (PC2); also elsewhere on the board
/A3: U5.26 (PC3); also elsewhere on the board
/A6: U5.19 (ADC6); also elsewhere on the board
/D2: U5.32 (PD2); also elsewhere on the board
/D3: U5.1 (PD3); also elsewhere on the board
/D5: U5.9 (PD5); also elsewhere on the board
/D6: U5.10 (PD6); also elsewhere on the board
/D8: U5.12 (PB0); also elsewhere on the board
/D9: U5.13 (PB1); also elsewhere on the board
/GPIO5: J7.29; also elsewhere on the board
/GPIO6: J7.31, TP13.1
/GPIO17: J7.11; also elsewhere on the board
/MISO: J5.1 (MISO), J7.12, U5.16 (PB4)
/MOSI: J5.4 (MOSI), J7.16, U5.15 (PB3)
/RX: J1.4, U5.30 (PD0)
/SCK: J5.3 (SCK), J7.18, U5.17 (PB5)
/SCL: J7.5, J7.37, TP6.1, U5.28 (PC5); also elsewhere on the board
/SDA: J7.3, TP5.1, U5.27 (PC4)
/TX: J1.5, U5.31 (PD1)
/Zero Voltage Diode/K: Q3.2 (S), R15.1; also elsewhere on the board
/uC-Power: J7.36, R33.1
/~RST: C5.2, J5.5 (~RST), J7.32, R12.2, SW3.1, U5.29 (~RESET/PC6)
GND: C4.2, C6.2, C7.1, C8.2, C9.2, C10.2, C11.2, C23.2, C24.2, C32.2, D2.2 (-), J1.1, J1.2, J5.6 (GND), J7.6, J7.9, J7.14, J7.20, J7.25, J7.30, J7.34, J7.39, Q2.2 (S), R14.1, R41.1, R50.1, SW3.2, TP2.1, TP11.1, U5.3 (GND), U5.5 (GND), U5.21 (GND); also elsewhere on the board
unnamed: C5.1, J1.6
unnamed: J6.1, J7.8
unnamed: J6.2, J7.10
unnamed: J7.13, TP12.1
unnamed: Q2.3 (D), Q3.1 (G), R15.2
unnamed: Q2.1 (G), R14.2, R33.2
unnamed: R50.2, R51.1, U5.22 (ADC7)
unnamed: C11.1, U5.20 (AREF)
unnamed: TP8.1, U5.14 (PB2)
unnamed: TP4.1, U5.11 (PD7)
unnamed: C7.2, U5.7 (XTAL1/PB6), Y1.1
unnamed: C9.1, U5.8 (XTAL2/PB7), Y1.2

Notes on the sheet:
A7 = Version Pin: See readAndPrintBoardRevision() for corresponding R value
(Underscore placed to keep the Net called SCL)

Parts:
Q4: DMG2305UX; SOT-23; LCSC C2940629
Q7: DMMT5401; SOT-23-6; LCSC C154733
R34: 47K; R_0805_2012Metric; LCSC C17713
R36: 10K; R_0805_2012Metric; LCSC C17414

Connections:
3.3V-RPi: Q4.3 (D), Q7.6 (E1); also elsewhere on the board
/Zero Voltage Diode/K: Q4.2 (S), Q7.5 (E2); also elsewhere on the board
GND: R34.1, R36.2; also elsewhere on the board
unnamed: Q4.1 (G), Q7.4 (C2), R34.2
unnamed: Q7.1 (C1), Q7.2 (B1), Q7.3 (B2), R36.1

Parts:
C20, C21, C22, C31: 100n; C_0805_2012Metric; LCSC C28233
CN5: Film End Eye; CONN-TH_3P-P2.54_DIBO_DB141R-2.54-3P; LCSC C2898755
CN6: Shaft Eye; CONN-TH_3P-P2.54_DIBO_DB141R-2.54-3P; LCSC C2898755
D3: No Film (re); LED_0805_2012Metric; LCSC C84256
D7: Shaft (re); LED_0805_2012Metric; LCSC C84256
J2: Shaft Eye; PinHeader_1x03_P2.54mm_Vertical
J3: Film End Eye; PinHeader_1x03_P2.54mm_Vertical
Q5, Q6: SS8050; SOT-23; LCSC C2150
R1, R6: 47K; R_0603_1608Metric; LCSC C25819
R3, R5: 100R; R_0603_1608Metric; LCSC C22775
R11, R29: 300R; R_0805_2012Metric; LCSC C17617
R20, R31: 470K; R_0805_2012Metric; LCSC C17709
R22, R30: 3K; R_0805_2012Metric; LCSC C17661
R24, R27: 3K3; R_0805_2012Metric; LCSC C26010
TP3: Film End; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm_named
TP10: Main Shaft; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm_named
U1, U2: QRE1113; OPTO-SMD_QRE1113GR; LCSC C232862
U9: 74LVC14; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
3.3V-uC: C20.1, CN5.3, CN6.3, R22.2, R30.2, U9.14 (VCC); also elsewhere on the board
/D2: U9.4; also elsewhere on the board
/D3: U9.8; also elsewhere on the board
/Sensors/3.3V-Eye1: J3.3, R5.1, R6.1
/Sensors/3.3V-Eye2: J2.3, R1.1, R3.1
GND: C20.2, C21.2, C22.2, C31.2, CN5.1, CN6.1, D3.1 (K), D7.1 (K), Q5.2 (E), Q6.2 (E), U9.7 (GND); also elsewhere on the board
GND1: J3.1, U2.2 (K), U2.4
GND2: J2.1, U1.2 (K), U1.4
unnamed: C21.1, R24.2, U9.3
unnamed: C22.1, R27.2, U9.9
unnamed: D3.2 (A), R11.1
unnamed: D7.2 (A), R29.1
unnamed: J2.2, R1.2, U1.3
unnamed: J3.2, R6.2, U2.3
unnamed: CN6.2, Q5.1 (B), R20.1
unnamed: Q5.3 (C), R20.2, R22.1, U9.1
unnamed: CN5.2, Q6.1 (B), R31.1
unnamed: C31.1, Q6.3 (C), R30.1, R31.2, U9.5
unnamed: R11.2, R27.1, TP3.1, U9.6
unnamed: R24.1, R29.2, TP10.1, U9.2
unnamed: R3.2, U1.1 (A)
unnamed: R5.2, U2.1 (A)

Parts:
C13: 100n; C_0805_2012Metric; LCSC C28233
D1: Power (gr); LED_0805_2012Metric; LCSC C2297
D11: Raspi Power; LED_0805_2012Metric; LCSC C84256
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_Pad_Via
J4: Resolution; PinHeader_1x03_P2.54mm_Vertical
J8: Target; PinHeader_1x03_P2.54mm_Vertical
R2, R4, R35, R40, R44, R45: 10K; R_0805_2012Metric; LCSC C17414
R7: 3K3; R_0805_2012Metric; LCSC C26010
R13, R21, R23, R32: 100K; R_0805_2012Metric; LCSC C149504
R25, R39: 47K; R_0805_2012Metric; LCSC C17713
R28, R37: 22K; R_0805_2012Metric; LCSC C17560
R38: 300R; R_0805_2012Metric; LCSC C17617
RV2: 10K; RES-ADJ-TH_3P-L10.0-W10.0-P2.50-L; LCSC C118954
RV4, RV5: 10K; RES-TH_RK09K1110A0J_short; LCSC C209767
SW1: Power; KEY-TH_1825027-8; LCSC Part C231320
SW2: Resolution; SW-TH_5P-P4.70_SS-12D11-G040; LCSC C17179527
SW4: Lamp; KEY-TH_4P-L12.0-W12.0-P5.0-LS12.5-EH-small; LCSC Part C93156
SW5: <<; KEY-TH_4P-L12.0-W12.0-P5.0-LS12.5-EH-small; LCSC Part C93156
SW6: Zoom; KEY-TH_4P-L12.0-W12.0-P5.0-LS12.5-EH-small; LCSC Part C93156
SW7: Stop; KEY-TH_4P-L12.0-W12.0-P5.0-LS12.5-EH-small; LCSC Part C93156
SW8: <; KEY-TH_4P-L12.0-W12.0-P5.0-LS12.5-EH-small; LCSC Part C93156
SW9: >; KEY-TH_4P-L12.0-W12.0-P5.0-LS12.5-EH-small; LCSC Part C93156
SW10: >>; KEY-TH_4P-L12.0-W12.0-P5.0-LS12.5-EH-small; LCSC Part C93156
SW11: Rec; KEY-TH_4P-L12.0-W12.0-P5.0-LS12.5-EH-small; LCSC Part C93156
SW12: Target; SW-TH_5P-P4.70_SS-12D11-G040; LCSC C17179527

Connections:
3.3V-RPi: R38.2; also elsewhere on the board
3.3V-uC: C13.1, J4.3, J8.3, R4.1, R7.2, R21.1, R32.1, R44.1, RV2.1, RV4.3, RV5.3, SW4.3, SW4.4, SW7.3, SW7.4; also elsewhere on the board
/A0: R23.1, SW4.1, SW4.2, SW5.1, SW5.2, SW6.1, SW6.2, SW8.1, SW8.2; also elsewhere on the board
/A1: R13.1, SW7.1, SW7.2, SW9.1, SW9.2, SW10.1, SW10.2, SW11.1, SW11.2; also elsewhere on the board
/A2: RV5.2; also elsewhere on the board
/A3: RV4.2; also elsewhere on the board
/A6: RV2.2; also elsewhere on the board
/GPIO5: J8.2, SW12.2 (B); also elsewhere on the board
/GPIO17: J4.2, SW2.2 (B); also elsewhere on the board
/SCL: SW1.2; also elsewhere on the board
GND: C13.2, D1.1 (K), D11.1 (K), J4.1, J8.1, R2.2, R13.2, R23.2, R35.2, R40.2, R45.2, RV2.3, RV4.1, RV5.1, SW1.1; also elsewhere on the board
unnamed: D1.2 (A), R7.1
unnamed: D11.2 (A), R38.1
unnamed: R21.2, R25.1, SW6.3, SW6.4
unnamed: R25.2, R28.1, SW5.3, SW5.4
unnamed: R28.2, R35.1, SW8.3, SW8.4
unnamed: R32.2, R39.1, SW9.3, SW9.4
unnamed: R37.1, R39.2, SW10.3, SW10.4
unnamed: R37.2, R40.1, SW11.3, SW11.4
unnamed: R4.2, SW2.1 (A)
unnamed: R2.1, SW2.3 (C)
unnamed: R44.2, SW12.1 (A)
unnamed: R45.1, SW12.3 (C)

Parts:
C1, C19, C25, C27: 10u; C_1210_3225Metric; LCSC C5156756
C2: 220u; CAP-SMD_BD12.5-L13.0-W13.0-FD; LCSC C249882
C3, C12, C14, C16, C33: 1u; C_0805_2012Metric; LCSC C22367837
C15: 470u; CAP-SMD_BD12.5-L13.0-W13.0-RD; LCSC C487135
C17: 22u; CP_Elec_6.3x7.7; LCSC C267472
C18, C26, C28, C30: 100n; C_0805_2012Metric; LCSC C28233
C34: 1n; C_0805_2012Metric; LCSC C15177
CN2: Motor; CONN-TH_2P-P5.08_KF142R-5.08-2P; LCSC C475144
CN3: Fan; CONN-TH_3P-P2.54_DIBO_DB141R-2.54-3P; LCSC C2898755
CN4: Lamp; CONN-TH_3P-P2.54_DIBO_DB141R-2.54-3P; LCSC C2898755
D4, D10: SS54; D_SMA; LCSC C22452
D5: 1N4148W; D_SOD-123; LCSC C81598
D6: Lamp (wh); LED_0805_2012Metric; LCSC C34499
D8: 1N4007; D_SOD-123F; LCSC C64898
D9: PMEG6020ER; D_SOD-123F; LCSC C52146084
L1: 47uH; IND-SMD_L13.8-W12.6_YSPI13XX; LCSC C497913
L2: 10uH; IND-SMD_L4.4-W4.2; LCSC C408339
Q1: CS12N06AE-G; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C442412
R8: 1K; R_0805_2012Metric; LCSC C17513
R9, R49: 47K; R_0805_2012Metric; LCSC C17713
R10, R26: 2K2; R_0805_2012Metric; LCSC C17520
R16: 270R; R_0805_2012Metric; LCSC C137558
R17: 71K5; R_0805_2012Metric; LCSC C101850
R18: 0.05R; R_2512_6332Metric; LCSC C127698
R19: 30K; R_0805_2012Metric; LCSC C17621
R42: 10K; R_0805_2012Metric; LCSC C17414
R43: 2K7; R_0805_2012Metric; LCSC C17530
R46, R47: 10K; R_1206_3216Metric; LCSC C17902
R48: 100K; R_0805_2012Metric; LCSC C149504
RV1, RV3: 10K; RES-ADJ-TH_3P-L10.0-W10.0-P2.50-L; LCSC C118954
RV6: 25K; RES-ADJ-TH_3P-L10.0-W10.0-P2.50-L; LCSC C118932
TP14, TP15, TP16: TestPoint; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm_named
U3: NH6375A50P; SOT-89-3_L4.5-W2.5-P1.50-LS4.2-BR; LCSC C7427778
U4: DRV8871DDA; Texas_HTSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.95x4.9mm_Mask2.4x3.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; LCSC C75864
U6: TL431; SOT-23; LCSC C181103
U7: XL4015; TO-263-5_TabPin3; LCSC C51661
U8: LM358; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C7950
U10: LGS5145; SOT-23-6_L2.9-W1.7-P0.95-LS2.8-BL; LCSC Part C5123971
U11: MCP1416; SOT-23-5; LCSC C83775

Connections:
5V-RPi: C28.1, U11.2 (Vdd); also elsewhere on the board
24VDC: C1.1, C2.1, C14.1, C17.1, C18.1, C25.1, C33.1, R46.2, U3.2 (VIN), U4.5 (VM), U7.5 (VIN), U10.5 (VIN); also elsewhere on the board
/D5: U4.3 (IN1); also elsewhere on the board
/D6: U4.2 (IN2); also elsewhere on the board
/D8: U10.4 (EN); also elsewhere on the board
/D9: R26.1, R49.1, U11.3 (IN); also elsewhere on the board
/Drivers/Lamp-GND: C34.2, CN4.1, Q1.5 (D), Q1.6 (D), Q1.7 (D), Q1.8 (D), R48.1, TP14.1
/Drivers/Mot-A: CN2.1, U4.6 (OUT1)
/Drivers/Mot-B: CN2.2, U4.8 (OUT2)
GND: C1.2, C2.2, C3.2, C12.2, C15.2, C17.2, C18.2, C19.2, C25.2, C27.2, C28.2, C30.1, C33.2, CN3.1, D4.2 (A), D6.1 (K), D8.2 (A), D9.2 (A), R9.2, R16.2, R18.1, R19.2, R43.1, R46.1, R47.1, R49.2, RV1.3, U3.1 (VSS), U4.1 (GND), U4.7 (GND), U4.9 (GND), U6.3 (A), U7.1 (GND), U8.4 (V-), U10.2 (GND), U11.4 (GND); also elsewhere on the board
unnamed: C15.1, C19.1, CN4.3, L1.2, R47.2, RV3.1, RV3.2, TP15.1
unnamed: CN4.2, TP16.1
unnamed: D4.1 (K), L1.1, U7.3 (SW)
unnamed: C16.1, D5.2 (A), U8.1
unnamed: D5.1 (K), R16.1, RV3.3, U7.2 (FB)
unnamed: D6.2 (A), R26.2
unnamed: C26.2, D9.1 (K), L2.1, U10.6 (SW)
unnamed: C27.1, D8.1 (K), D10.2 (A), L2.2, R42.1
unnamed: CN3.3, D10.1 (K)
unnamed: C30.2, Q1.4 (G), R8.1, R9.1
unnamed: R17.2, RV1.1
unnamed: R42.2, RV6.1, RV6.2
unnamed: C3.1, R10.1, U3.3 (VOUT), U8.8 (V+)
unnamed: R19.1, U4.4 (ILIM)
unnamed: C12.1, R10.2, R17.1, U6.1 (K), U6.2 (REF)
unnamed: C14.2, U7.4 (VC)
unnamed: C34.1, Q1.1 (S), Q1.2 (S), Q1.3 (S), R18.2, R48.2, U8.3 (+)
unnamed: C16.2, RV1.2, U8.2 (-), U8.5 (+)
unnamed: U8.6 (-), U8.7
unnamed: C26.1, U10.1 (BST)
unnamed: R43.2, RV6.3, U10.3 (FB)
unnamed: R8.2, U11.5 (OUT)

Notes on the sheet:
Current
Vout = 0.812*((Rf+Rg)/Rg) here 3.8-11.3 V
Voltage

Board: 4 copper layers, 122.2 x 115.1 mm, 166 parts (4 on the bottom side), 100 nets.

## Commit log (part)

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2026-01-11 new hex files
2026-01-11 Allow exiting WB Mode properly
2026-01-11 Try to avoid some led flashing during boot
2026-01-11 cache the hex sha256 to avoid redundant acvrdude reads (slows down service start)
2026-01-12 Settings Menu Refactoring 1/n
2026-01-12 pollButton did not liek long presses...
2026-01-12 wokring around conflicting button handlers
2026-01-12 braces...
2026-01-12 Removed the leftover reference to menuEnterPending
2026-01-12 More navigation fixes
2026-01-13 Do not track semphores
2026-01-13 menu consistency
2026-01-13 try to miss less button pushes
2026-01-13 makethe Preview WB list vertical
2026-01-13 Threading issues
2026-01-13 fix a numpy crash, remove legacy settings entry, remove threading
2026-01-13 Removed duplicate pollButtons() calls
2026-01-13 removing dead code
2026-01-13 minor issues
2026-01-13 fix leaving WB mode
2026-01-13 Show current WB K in the main menu
2026-01-13 Add ButtonLabels
2026-01-13 buttons are a bit wider than the screen
2026-01-13 Add Target Soft Switching
2026-01-13 Let Factory Reset delete prefs
2026-01-13 Fix Target Mode Menu Nav
2026-01-13 fix pairing mode
2026-01-13 reset the ino after servce restart
2026-01-13 allow service restarts even during failng io
2026-01-13 Update status screen correctly to ready-to-scan-net once in host mode
2026-01-13 screen caching issue
2026-01-13 Don't show ready-to-scan-net whiel in menu
2026-01-14 More error screens
2026-01-14 Granular Connectivity Checks before allowing Host mode
2026-01-14 restore previous target after connectivity failure
2026-01-14 debug navigation oddity
2026-01-14 Fix nnavigation after failed host connectivity check
2026-01-14 fix log spam
2026-01-14 Better error handling for cached target prefs
2026-01-14 more globals
2026-01-14 copy
2026-01-14 Tell the ino that we jumped into a menu
2026-01-14 more sorcery to jump intoa submenu
2026-01-14 remove unneccessary states, simplify code, try submenu reentrysupport once more
2026-01-14 sheesh
2026-01-14 i2c comms hardening, timing
2026-01-14 Update pair.sh with new copy to start OTP
2026-01-14 Better Help on network failures
2026-01-14 Fix line breaks
2026-01-14 branding PIL screens
2026-01-14 resizing fix
2026-01-14 don't scale the logo
2026-01-18 small helper tobootstrap fuses
2026-01-18 Dynamic screens 0.8, skip hex caching for now
2026-01-18 ignore .target mode setting
2026-01-21 Re-enable HEX-caching
2026-01-21 Move Resoluton and Shutter SPeed to top left
2026-01-21 less line spacing
2026-01-21 yet less line spacing
2026-01-21 improve font padding
2026-01-21 top top left
2026-01-21 spacing nudging
2026-01-21 fix the version number pos
2026-01-28 add brown-out debugging
2026-01-28 add sleep trigger logging, change sleep threshold to 2s
2026-01-28 make i2c retires a bit faster to not starve the cam pipeline. Revert the 2s sleep threshold
2026-01-28 seems like the PORF=1 can be cured by reducing motor speed...
2026-01-28 remove unused screens
2026-01-29 attempting to fix pishrink docker path issue
2026-01-29 compress the shrunk image
2026-01-29 attempt to fix skiping of zeroing
2026-01-29 copy pairing tools to /mnt/usb if system is not paired yet
2026-01-29 add script to understand image size diffs
2026-01-29 skip swap file when imaging
2026-01-29 Make "Installer" work independent from repo
2026-01-29 Extract, track and persist Installer icon
2026-01-29 Improve Installer, store .dotfiles in Application Support (for Installer runs)
2026-01-29 Installer fixes
2026-01-29 do not stop bundle cretaion too early
2026-01-30 recreate app bundle if parent dir still exists
2026-01-30 this one is nasty
2026-01-30 No \r in filenames!
2026-01-30 Show exposure time on "insert film" screen, too
2026-01-30 Move Installer app out of repo root
2026-01-30 rename the template instead of its copy
2026-01-31 Bind lsyncs to eth, introduce wlan setup
2026-01-31 patch existing lsyncd.conf to bind to eth0
2026-01-31 do not scan for SSIDs on theif that provides the AP already
2026-01-31 permissions for ssids
2026-01-31 avoid if races, debug output++
2026-01-31 add PolicyKit rule to allow pi performing NetworkManager actions
2026-01-31 allow reconnects
2026-01-31 use wifi-sec.key-mgmt
2026-01-31 aloow revealing password while typing
2026-01-31 Rewrite nmcli client, better debug logging
2026-01-31 betetr timeout handling, clenaer disconnect, yet more logging
2026-01-31 fixing menu hangs afetr connect
2026-01-31 add wifi logs to debug log, stop autocarot when typing in password
2026-01-31 fix portal exit, more logging – attempting fix for menu exit
2026-01-31 fixing menu exit, confirming reconnection
2026-01-31 remove wifi settings on factory reset
2026-01-31 imrpove connection logging
2026-01-31 allow pairing via wifi
2026-01-31 turn wifi off when ssh-ing to avoid hostname/ip ambiguity
2026-01-31 don't track dotfiles
2026-01-31 exclude raspi/dotfiles from image
2026-01-31 remind to not image in host mode
2026-01-31 harden imaging script's ssh connections
2026-02-01 R8 -> 1K
2026-02-01 add C30
2026-02-01 Add C31 to U9 to form another low pass
2026-02-01 R2/R4 -> 10K
2026-02-01 Rename Target Switch to Resolution, add actual Target Switch
2026-02-01 GND TP @ GPIO
2026-02-01 Migrated to Kicad 9
2026-02-01 reassigned customfootprints to now gobal library
2026-02-01 Remove Pin numbers from mechanical pins, add unplaced U9 units as NC
2026-02-01 Add new componented since Rev D
2026-02-01 D7 is unused
2026-02-01 Massive rearrangement :)
2026-02-01 Bigger Ears, DRc not quite happy yet
2026-02-01 DRC much happier
2026-02-02 DRC mostly happy
2026-02-02 Massive LampGND
2026-02-04 Major refactoring to better EMV in progress
2026-02-05 Refactored LED Driver: Switch behind the buck, reduce EMV
2026-02-05 Add Board Revision Detection
2026-02-05 Saving memory by moving strings from ram to flash
2026-02-05 Added Board Revision Detector
2026-02-05 All better caps, more suitabel LDO for 50-> 5V
2026-02-06 DRC almost happy
2026-02-06 DRC happy!
2026-02-06 Routing optimizations
2026-02-18 Only start film end detection once some film was inserted for 30 seconds (to avoid a non-registering loop former pull eing misread)
2026-02-18 Fixing this 30s run threshold
2026-02-18 Allow sleep when no drive is connected yet
2026-02-18 A better approach to allow sleeping w/o a drive
2026-02-18 Make "no drive connected" actually (more) blocking
2026-02-19 Block scanning entirely if no valid target is available
2026-02-19 Reject scanning locally on the ino
2026-02-19 Preserve last state when rejecting a scan
2026-02-19 Detect and handle a missingcamera
2026-02-19 Don't crash on camera detection
2026-02-19 Do not allow zoom nor Lamp w/o a camera
2026-02-19 Use tty for no-camera warning
2026-02-19 turn wifi off before doing a host connectivity check (we are bound to eth0)
2026-02-19 Assure atomic capture: Do not advance while shooting and vice versa
2026-02-19 revert the buffer draining to see if its necessary
2026-02-19 try minor latency since the shaft has a mass
2026-02-19 Revert ino changes to restore original timing
2026-02-19 simpler approach to fix long exp times
2026-02-20 sync fs to not lose ~60 frames when unplugging too early
2026-02-20 Show Exposure Time on "No Drive connected" Screen
2026-02-20 Do not warn about disconnected drives while in menu
2026-02-20 Remove a delay in the pollButtons since the i2crevceive was calling that
2026-02-20 attemptto fix shutter speed display
2026-02-20 l10n!
2026-02-20 test smaller logo
2026-02-20 reduce HUD brightness
2026-02-20 yet darker
2026-02-21 Exlude locale and mcu hash from image
2026-02-21 Do not checjk for host if target is usb
2026-02-21 Try imaging without fsfreeze
2026-02-21 Do not run firstboot on the imaged raspi to keep ssh working
2026-02-21 Testng higher PWM (62.5 kHz) ith millis scaling
2026-02-22 Fetch tags correctly when not in dev mode
2026-02-22 show more tags in dev mode
2026-02-22 fixing ssh foo
2026-02-22 Do not stop avahi to stay reacahble via host name during imaging
2026-02-26 3D Parts from Sebastian
2026-02-26 3D readme
2026-02-28 3D Updates
2026-02-28 Attempt to fix a race when the disk runs full and we don't properly stop the engines
2026-02-28 Attempting to guard Shaft ISRs a bit
2026-02-28 Try no break
2026-02-28 well try again
2026-02-28 Attempt a soft break
2026-02-28 brake ramp 30 ms
2026-02-28 fixing a race causing occasionally swapped frames
2026-02-28 Try shorter ramp to avoid the advance during capture
2026-02-28 shoot right on ISR trigger
2026-02-28 try 10 ms ramps with new order
2026-02-28 drain the buffer before capture to not see motion blur from the past
2026-02-28 try long ramp to stress test
2026-02-28 Trying 20 ms
2026-03-01 start slow, break fast
2026-03-01 COntrolled frame buffer draining
2026-03-01 Detach ISR after stopping to avoid double action
2026-03-01 Drain differently, the cam clock seems to drift
2026-03-01 pop stale frames
2026-03-01 Trying a slower approach
2026-03-01 wait for motor settle
2026-03-01 attempt to fix timing issues
2026-03-01 Change offset from 1 to tow frames
2026-03-01 attempt to fix an i2c deadlock
2026-03-01 fixing a double global declaration
2026-03-01 Detach ISR on Stop
2026-03-01 add debug code
2026-03-01 yet more debug code
2026-03-01 less noise
2026-03-01 add a minimum age distance for 4K mode, plus add a baase of 2 frames dropped.
2026-03-01 Finetuning the drainer
2026-03-01 2f/150ms (4K)
2026-03-01 135ms
2026-03-01 150ms
2026-03-01 +20ms
2026-03-01 force log flushing in host mode
2026-03-01 log directly to journald
2026-03-02 revert the live logging, ssh is the bottleneck. deal with it.
2026-03-02 Disable Drain Logging
2026-03-02 Fixes an OTA Updater bug that caused permission problems
2026-03-02 gitignore
2026-03-02 Do not make scanner.log part of the image
2026-03-04 add a capture latency menu, replacing static delays
2026-03-04 improve i2c failue tolerance
2026-03-04 Try a bigger 4K floor
2026-03-04 Fix min latency conversion from 2K to 4K mode
2026-03-04 switching capture latency to (picam) frames, not ms. More transpaent and resolution agnostic.
2026-03-05 add comments
2026-03-05 Add Motor Calibration Routine
2026-03-05 Motor calibration, raspi part
2026-03-05 Try a 25 ms ramp on stepping to reduce heat dissipation
2026-03-05 Make i2c yet more recovering
2026-03-05 remove dead ino code
2026-03-05 Remove dead python code
2026-03-05 Backup controlelr settings in ino eeprom to survice reimaging
2026-03-06 fixing a i2c race with eeprom sync
2026-03-06 flexible wait for eeprom reads
2026-03-06 More races and bug fixes on the eebackup approach...
2026-03-06 Do not nil the EEPROM on falsh, doh
2026-03-06 Debug logging for i2c foo
2026-03-06 Add some i2c handshaking / NACK
2026-03-06 Fix the fuse setting
2026-03-06 more i2c fixes -.-
2026-03-06 simplify error handling
2026-03-06 Settinge menu pleeeeease
2026-03-06 Yet more comms fix attempts
2026-03-06 simplify and retry
2026-03-06 DOH off by one
2026-03-06 Move motor calibration to eeprom
2026-03-06 Show Motor Calibration Screen
2026-03-06 Fix HTTS override in tag checking even if devkeys are present
2026-03-06 typo
2026-03-06 2 sec for the Settings menu vs 3
2026-03-08 Added a scan-idle watchdog to circumvent i2c jams
2026-03-08 0.9.8 Release notes
2026-03-08 change log level
2026-03-08 Leave Parining Menu after timeout
2026-03-08 Add FR, ES, IT locales
2026-03-08 name collision
2026-03-08 reduce log bleeding
2026-03-08 Settings Menu Cleanup
2026-03-08 add spacing
2026-03-08 pixel peeping
2026-03-08 fix UnboundLocalError
2026-03-08 Stemaline settings formatting
2026-03-08 one more unBouneException
2026-03-08 fix frimware menu exit
2026-03-08 Adding missing l10n
2026-03-08 Release NOtes, remove debug output
2026-03-08 Transfer Board Revision to raspi world
2026-03-08 Call GPIO5 "Target Switch" on Rev E+ boards
2026-03-08 Get Board Rev after Init Values
2026-03-08 baord revision race
2026-03-08 Resolve Project Settings Presets
2026-03-12 fixing the fps HUD accuracy. Doh!
2026-04-26 remove hosname artifacts on unpairing
2026-04-26 Update Pairing App on USB drive if its outdated
2026-04-26 Update the Installer bundle also when paired
2026-04-26 really really update :)
2026-04-26 cleanup resolve folder
2026-04-26 Exposed Resources Cleanup
2026-04-26 Exposed 3D Parts and Davinci Resources to USB drive
2026-04-26 Documentation
2026-04-30 Adding Sebastian's Macro Focus Unit
2026-04-30 unifying Release Notes
2026-04-30 Store URL
